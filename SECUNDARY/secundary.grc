options:
  parameters:
    author: alvaro
    generate_options: qt_gui
    id: secundary
    output_language: python
    title: SECUNDARY
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_ofdm(occupied_carriers, 1, length_tag_key,)
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=packet_length_tag_key, frame_len_tag_key=length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_entry
  parameters:
    label: rx_gain
    type: real
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: tx_gain
  id: variable_qtgui_entry
  parameters:
    label: tx_gain
    type: real
    value: '50'
  states: {}
- name: analog_frequency_modulator_fc_0_0_0_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: analog_frequency_modulator_fc_0_0_0_0_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: fft_len+fft_len//4
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: fft_len+fft_len//4
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '50e-3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '50e-3'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: length_tag_key
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: length_tag_key
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_0_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_1_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: packet_length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_1_0_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: packet_length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_2_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'True'
    type: complex
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'True'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: length_tag_key
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: length_tag_key
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: length_tag_key
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: length_tag_key
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_constellation_decoder_cb_0_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_0_0_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_1_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_1_0_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {}
- name: digital_header_payload_demux_0_0_0_0_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: fft_len//4
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: length_tag_key
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_header_payload_demux_0_0_0_0_0_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: fft_len//4
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: length_tag_key
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_chanest_vcvc_0_0_0_0_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_chanest_vcvc_0_0_0_0_0_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0_0_0_0_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0_0_0_0_0_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_1_0_0_0_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_1_0_0_0_0_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_header_0_0_0_0
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_header_0_0_0_0_0
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_payload_0_0_0_0
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: packet_length_tag_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_serializer_vcc_payload_0_0_0_0_0
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: packet_length_tag_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0_0_0_0_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0_0_0_0_0_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_packet_headerparser_b_0_0_0_0_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: digital_packet_headerparser_b_0_0_0_0_0_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: length_tag_key
  states: {}
- name: digital_protocol_formatter_bb_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: length_tag_key
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "from gnuradio import gr\nimport re\nimport numpy as np\nimport time\nimport re\n\n\nclass mac(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name=\"MAC\",\n            in_sig=None,\n            out_sig=None\n            )\n        # Message portsw\n        self.message_port_register_in(gr.pmt.intern(\"packet\"))\n        self.message_port_register_out(gr.pmt.intern(\"ack\"))\n        self.set_msg_handler(gr.pmt.intern('packet'), self.ack_sender)\n        self.packet_num_received = 0\n        self.shift = 0\n        \n    def ack_sender(self, msg):\n        \n        msg_vec = gr.pmt.cdr(msg)\n        # Convert the PMT vector into a Python list to extract the number\n        msg_data = []\n        for i in range(48):\n            msg_data.append(gr.pmt.u8vector_ref(msg_vec, i))\n        a = 0           \n        for i in msg_data[1:]:\n            a = a + i\n        \n        self.packet_num_received =  a * 255 + msg_data[0]\n\n                \n        # Introduce the same received number into the pdu to send the ACK\n        send_str = self.packet_num_received.to_bytes(48, 'little', signed=True) \n        send_pmt = gr.pmt.make_u8vector(len(send_str), 0)\n   \n        for i in range(len(send_str)):\n            gr.pmt.u8vector_set(send_pmt, i, send_str[i])\n        \n        msg = gr.pmt.cons(gr.pmt.PMT_NIL, send_pmt)\n        #print(\"ACK from packet number \" + str(self.packet_num_received) + \" sended\")\n        self.message_port_pub(gr.pmt.intern('ack'), msg)\n\n\n"
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "from gnuradio import gr\nimport numpy as np\nimport statistics\nimport random\n\nclass mac(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name=\"MAC\",\n            in_sig=[],\n            out_sig=None\n            )\n\n        # Message ports\n        self.message_port_register_out(gr.pmt.intern(\"channel_up\"))\n        self.message_port_register_out(gr.pmt.intern(\"channel_down\"))\n        self.message_port_register_out(gr.pmt.intern(\"transmit_packet\"))\n        self.message_port_register_in(gr.pmt.intern(\"time_unit\"))\n        self.message_port_register_in(gr.pmt.intern(\"ack\"))\n        self.set_msg_handler(gr.pmt.intern('time_unit'), self.send_packet)\n        self.set_msg_handler(gr.pmt.intern('ack'), self.ack_handler)\n        self.interation_wait_ack = 2 # interation_wait_ack in seconds\n        self.packet_num_send = 0\n        self.packet_num_received = -1\n        self.transmit = True\n        self.channels = {\n            \"ch1\": [2410000000,2410000000],\n            \"ch2\": [2430000000,2440000000],\n            \"ch3\": [2450000000,2460000000],\n            \"ch4\": [2470000000,2480000000],\n            \"ch5\": [2490000000,2500000000],}\n\n        self.channel_up = self.channels['ch1'][0]\n        self.channel_down = self.channels['ch1'][1]\n        self.message_port_pub(gr.pmt.intern('channel_up'), gr.pmt.to_pmt({'freq': self.channel_up }))\n        self.message_port_pub(gr.pmt.intern('channel_down'), gr.pmt.to_pmt({'freq': self.channel_down }))\n\n\n    def ack_handler(self, msg):\n        \n        msg_vec = gr.pmt.cdr(msg)\n        # Convert the PMT vector into a Python list\n        msg_data = []\n        for i in range(48):\n            msg_data.append(gr.pmt.u8vector_ref(msg_vec, i))\n            \n        a = 0           \n        for i in msg_data[1:]:\n            a = a + i\n        self.packet_num_received =  a * 255 + msg_data[0]\n\n        # print(self.packet_num_received)\n\n    def send_packet(self, msg):\n       \n           # White space and ACK of the last packet received\n           if (self.transmit == True):\n           \n               # Set up the pdu body with the number of the packet\n               send_str = self.packet_num_send.to_bytes(48, 'little', signed=True) \n               send_pmt = gr.pmt.make_u8vector(len(send_str), 0)\n           \n               for i in range(len(send_str)):\n                   gr.pmt.u8vector_set(send_pmt, i, send_str[i])\n           \n               msg = gr.pmt.cons(gr.pmt.PMT_NIL, send_pmt)   \n               self.message_port_pub(gr.pmt.intern('transmit_packet'), msg)\n               \n               # Decrease the time out in one unit, take down the transmit flag and print sended packet number\n               self.interation_wait_ack -= 1\n               self.transmit = False\n               print (\"Transimitting packet number \" + str(self.packet_num_send))\n               \n           # ACK Received, reestablish time out, increase packet number and flag\n           elif (self.packet_num_received == self.packet_num_send):\n               self.interation_wait_ack = 2\n               self.packet_num_send += 1\n               self.transmit = True\n               print (\"ACK of \" + str(self.packet_num_send) + \" received\")\n           \n           elif (self.interation_wait_ack > 0 and self.packet_num_received != self.packet_num_send):\n               self.interation_wait_ack -= 1\n               self.transmit = False\n           \n           else:\n               self.transmit = True\n               print (\"NACK of \" + str(self.packet_num_send) + \" received\")\n               print (\"Retransmitting packet number \" + str(self.packet_num_send))\n               self.interation_wait_ack = 2\n     \n    def work(self, input_items, output_items):\n\n        # if statistics.mean(self.l) > 500000:\n        #     self.channel = random.choice(list(self.channels.values()))\n        #     self.message_port_pub(gr.pmt.intern('channel'), gr.pmt.to_pmt({'freq': self.channel }))\n        # else:\n        #     self.message_port_pub(gr.pmt.intern('channel'), gr.pmt.to_pmt({'freq': self.channel }))\n\n        #print (str(statistics.mean(self.l)) + \" UP: \" + str(self.channel_up)+ \" DOWN: \" + str(self.channel_down))\n        return ()\n        \n       \n  \n\n"
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0_0_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1_0_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: header_bits
  id: virtual_sink
  parameters:
    stream_id: Header Bits B210 RX
  states: {}
- name: header_bits_0
  id: virtual_sink
  parameters:
    stream_id: Header Bits B210 TX
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.digital.utils import tagged_streams
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: '50000'
    fc: '4000000000'
    fftsize: '64'
    name: SECUNDARY RX
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '2450000000'
    dev_addr: serial=F5C243
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: length_tag_key
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '2400000000'
    dev_addr: serial=F5C234
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: length_tag_key
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: '2450000000'
    dc_offs_enb0: '""'
    dev_addr: serial=F5C234
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: '2400000000'
    dc_offs_enb0: '""'
    dev_addr: serial=F5C243
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Time Domain B210 RX
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bits B210 RX
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM B210 RX
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM B210 TX
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: Payload Bits B210 TX
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: Time Domain B210 TX
  states: {}
- name: virtual_sink_0_1_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Header Stream Secundary TX
  states: {}
- name: virtual_sink_0_1_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Header Stream Secundary RX
  states: {}
- name: virtual_sink_1_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: SENSING IN
  states: {}
- name: virtual_sink_1_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: Payload IQ Secundary TX
  states: {}
- name: virtual_sink_1_0_0_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload IQ Secundary RX
  states: {}
- name: virtual_sink_1_0_0_0_2_0
  id: virtual_sink
  parameters:
    stream_id: CHANNEL SECUNDARY UPSTREAM
  states: {}
- name: virtual_sink_1_0_0_0_2_0_0_0
  id: virtual_sink
  parameters:
    stream_id: PACKET RX
  states: {}
- name: virtual_sink_1_0_0_0_2_0_1
  id: virtual_sink
  parameters:
    stream_id: CHANNEL SECUNDARY DOWNSTREAM
  states: {}
- name: virtual_sink_1_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Stream Secundary TX
  states: {}
- name: virtual_sink_1_1_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Stream Secundary RX
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Bits B210 RX
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Bits B210 RX
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM B210 RX
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM B210 TX
  states: {}
- name: virtual_source_0_0_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: CHANNEL SECUNDARY DOWNSTREAM
  states: {}
- name: virtual_source_0_0_0_0_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: CHANNEL SECUNDARY UPSTREAM
  states: {}
- name: virtual_source_0_0_0_0_0_1_0_2_0
  id: virtual_source
  parameters:
    stream_id: PACKET RX
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: Payload Bits B210 TX
  states: {}
- name: virtual_source_0_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Payload IQ Secundary TX
  states: {}
- name: virtual_source_0_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Payload IQ Secundary RX
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Header Bits B210 TX
  states: {}
- name: virtual_source_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Header Stream Secundary TX
  states: {}
- name: virtual_source_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Header Stream Secundary RX
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Stream Secundary TX
  states: {}
- name: virtual_source_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Stream Secundary RX
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0, '0']
- [analog_frequency_modulator_fc_0_0_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0, '1']
- [blocks_delay_0_0_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '1']
- [blocks_message_strobe_0, strobe, epy_block_0_0, time_unit]
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_tag_gate_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_0, '0', digital_header_payload_demux_0_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_0_0, '0', digital_header_payload_demux_0_0_0_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_repack_bits_bb_0_2, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0, '0', blocks_repack_bits_bb_0_2_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0, '0', digital_protocol_formatter_bb_0_0, '0']
- [blocks_repack_bits_bb_0_0_1, '0', header_bits, '0']
- [blocks_repack_bits_bb_0_0_1_0, '0', header_bits_0, '0']
- [blocks_repack_bits_bb_0_1_0_0_0_0, '0', blocks_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_repack_bits_bb_0_1_0_0_0_0_0, '0', blocks_tagged_stream_to_pdu_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_2, '0', virtual_sink_0_0, '0']
- [blocks_repack_bits_bb_0_2_0, '0', virtual_sink_0_0_1, '0']
- [blocks_tag_gate_0, '0', uhd_usrp_sink_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_0, '0']
- [blocks_tag_gate_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_tag_gate_0_0, '0', virtual_sink_0_1, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_tagged_stream_to_pdu_0_0_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_tagged_stream_to_pdu_0_0_0, pdus, virtual_sink_1_0_0_0_2_0_0_0, '0']
- [blocks_tagged_stream_to_pdu_0_0_0_0, pdus, epy_block_0, packet]
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [digital_chunks_to_symbols_xx_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0_0_0, '0', digital_packet_headerparser_b_0_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0_0_0_0, '0', digital_packet_headerparser_b_0_0_0_0_0_0, '0']
- [digital_constellation_decoder_cb_1_0_0_0_0, '0', blocks_repack_bits_bb_0_1_0_0_0_0, '0']
- [digital_constellation_decoder_cb_1_0_0_0_0_0, '0', blocks_repack_bits_bb_0_1_0_0_0_0_0, '0']
- [digital_header_payload_demux_0_0_0_0_0, '0', virtual_sink_0_1_0_0_0_0, '0']
- [digital_header_payload_demux_0_0_0_0_0, '1', virtual_sink_1_1_0_0_0, '0']
- [digital_header_payload_demux_0_0_0_0_0_0, '0', virtual_sink_0_1_0_0_0_0_0, '0']
- [digital_header_payload_demux_0_0_0_0_0_0, '1', virtual_sink_1_1_0_0_0_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0_0, '0', fft_vxx_0_0, '0']
- [digital_ofdm_chanest_vcvc_0_0_0_0_0, '0', digital_ofdm_frame_equalizer_vcvc_0_0_0_0_0, '0']
- [digital_ofdm_chanest_vcvc_0_0_0_0_0_0, '0', digital_ofdm_frame_equalizer_vcvc_0_0_0_0_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0_0_0_0_0, '0', digital_ofdm_serializer_vcc_header_0_0_0_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0_0_0_0_0_0, '0', digital_ofdm_serializer_vcc_header_0_0_0_0_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_1_0_0_0_0, '0', digital_ofdm_serializer_vcc_payload_0_0_0_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_1_0_0_0_0_0, '0', digital_ofdm_serializer_vcc_payload_0_0_0_0_0, '0']
- [digital_ofdm_serializer_vcc_header_0_0_0_0, '0', digital_constellation_decoder_cb_0_0_0_0_0, '0']
- [digital_ofdm_serializer_vcc_header_0_0_0_0_0, '0', digital_constellation_decoder_cb_0_0_0_0_0_0, '0']
- [digital_ofdm_serializer_vcc_payload_0_0_0_0, '0', virtual_sink_1_0_0_0_1_0, '0']
- [digital_ofdm_serializer_vcc_payload_0_0_0_0_0, '0', virtual_sink_1_0_0_0_1_0_0, '0']
- [digital_ofdm_sync_sc_cfb_0_0_0_0_0, '0', analog_frequency_modulator_fc_0_0_0_0_0, '0']
- [digital_ofdm_sync_sc_cfb_0_0_0_0_0, '1', digital_header_payload_demux_0_0_0_0_0, '1']
- [digital_ofdm_sync_sc_cfb_0_0_0_0_0_0, '0', analog_frequency_modulator_fc_0_0_0_0_0_0, '0']
- [digital_ofdm_sync_sc_cfb_0_0_0_0_0_0, '1', digital_header_payload_demux_0_0_0_0_0_0, '1']
- [digital_packet_headerparser_b_0_0_0_0_0, header_data, digital_header_payload_demux_0_0_0_0_0, header_data]
- [digital_packet_headerparser_b_0_0_0_0_0_0, header_data, digital_header_payload_demux_0_0_0_0_0_0, header_data]
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_0_0_1, '0']
- [digital_protocol_formatter_bb_0_0, '0', blocks_repack_bits_bb_0_0_1_0, '0']
- [epy_block_0, ack, blocks_message_debug_0_1, print_pdu]
- [epy_block_0, ack, blocks_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_0_0, channel_down, virtual_sink_1_0_0_0_2_0_1, '0']
- [epy_block_0_0, channel_up, virtual_sink_1_0_0_0_2_0, '0']
- [epy_block_0_0, transmit_packet, blocks_message_debug_0_0, print_pdu]
- [epy_block_0_0, transmit_packet, blocks_pdu_to_tagged_stream_0_0_0, pdus]
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [fft_vxx_0_0_0_0_0_0, '0', digital_ofdm_chanest_vcvc_0_0_0_0_0, '0']
- [fft_vxx_0_0_0_0_0_0_0, '0', digital_ofdm_chanest_vcvc_0_0_0_0_0_0, '0']
- [fft_vxx_1_0_0_0_0, '0', digital_ofdm_frame_equalizer_vcvc_1_0_0_0_0, '0']
- [fft_vxx_1_0_0_0_0_0, '0', digital_ofdm_frame_equalizer_vcvc_1_0_0_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_delay_0_0_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', digital_ofdm_sync_sc_cfb_0_0_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_sink_x_0_0, '0']
- [uhd_usrp_source_0_0, '0', virtual_sink_1_0_0_0_0, '0']
- [uhd_usrp_source_0_0_1, '0', blocks_delay_0_0_0_0_0_0, '0']
- [uhd_usrp_source_0_0_1, '0', digital_ofdm_sync_sc_cfb_0_0_0_0_0_0, '0']
- [virtual_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [virtual_source_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_0_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0_0, '0']
- [virtual_source_0_0_0_0_0_1_0_0, '0', uhd_usrp_source_0_0, command]
- [virtual_source_0_0_0_0_0_1_0_0_0, '0', uhd_usrp_sink_0_0, command]
- [virtual_source_0_0_0_0_0_1_0_2_0, '0', epy_block_0_0, ack]
- [virtual_source_0_0_1, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [virtual_source_0_0_1_0_0_0_0, '0', digital_constellation_decoder_cb_1_0_0_0_0, '0']
- [virtual_source_0_0_1_0_0_0_0_0, '0', digital_constellation_decoder_cb_1_0_0_0_0_0, '0']
- [virtual_source_0_1, '0', digital_chunks_to_symbols_xx_0_1, '0']
- [virtual_source_0_1_0_0_0_0, '0', fft_vxx_0_0_0_0_0_0, '0']
- [virtual_source_0_1_0_0_0_0_0, '0', fft_vxx_0_0_0_0_0_0_0, '0']
- [virtual_source_1_0_0_0_0, '0', fft_vxx_1_0_0_0_0, '0']
- [virtual_source_1_0_0_0_0_0, '0', fft_vxx_1_0_0_0_0_0, '0']

metadata:
  file_format: 1
